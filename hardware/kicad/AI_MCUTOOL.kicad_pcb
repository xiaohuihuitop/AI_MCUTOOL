# Repository xiaohuihuitop/AI_MCUTOOL

File README.md:

# MCU开发辅助工具

通过Wi-Fi及原生USB，向AI提供五路按键模拟、供电通路选择、充电器插拔模拟、电压电流测量和目标串口交互能力。

## 版本与下载

**桌面／后台／MCP 1.1.1，配套固件 0.1.4。** [下载 1.1.1 正式版](https://github.com/xiaohuihuitop/AI_MCUTOOL/releases/tag/v1.1.1) · [版本列表](https://github.com/xiaohuihuitop/AI_MCUTOOL/releases)。1.0.0 和 0.5.5 可在工作台预下载并安装更新，0.5.1～0.5.4 可在托盘检查更新。0.6.0-rc.1、0.5.0 及更早版本首次升级请使用 1.1.1 安装器。已有 0.1.4 固件可继续使用。

1.1.1 起，从工作台安装桌面更新会自动关闭空闲的 AI 工具连接。有记录或板上任务时可选择「继续运行」或「停止并安装」。正在写入固件时，确认后会等工具板重连并读回新版本。

上位机 1.1.0 新增工具板固件升级：连接工具板后，工作台检查并预下载适配的正式固件。通过 USB 连接、取得操作权并确认升级后，工作台写入固件，自动重连同一块板并显示实际版本。[固件升级说明](docs/桌面版使用说明.md)。

1.0.0 同时提供板图、桌面更新和三路板上时序。通过 MCP 的 `run_output_sequence` 一次下发每步状态、持续时间、重复次数和收尾状态，由 ESP32 计时。已有产品端带载波形，三路独立开关边沿的 ±5 ms 仍待完整验收。[三路时序协议](protocol/设备协议.md#三路开关板上时序固件-014)。

六路固定每路每秒10次。电池电压、电流共用双轴图；四路电压另有独立页面，支持每路比例、偏移、颜色和曲线显隐。两组分别开始/暂停、清空、导出CSV，保留最近4小时完整采样；电池图支持A/B游标、极值、时间加权平均与区间净电量。详细规则见[图表使用说明](docs/上位机界面与图表使用说明.md)。

0.5.0 增加板上充电插拔循环。选择真实电池并关闭充电后，通过 MCP 的 `run_charge_cycle` 一次指定接通毫秒、断开毫秒和有限次数。电脑失联后板子继续执行，最后断开充电。[协议和验收口径](protocol/设备协议.md)

## AI自动安装与接入

把本仓库交给AI，并说明：

> 请按README安装MCU TOOL正式桌面版和配套Skill，接入我正在使用的AI客户端，完成只读MCP自检。先不要执行按键、供电、充电或串口发送；连接工具板时核对我指定的设备。

**Windows 10/11 x64** 下，在仓库根目录运行以下命令。使用Windows自带的PowerShell 5.1即可，PowerShell 7也支持：

```powershell
# Codex：安装桌面、运行环境、Skill，登记MCP并打开工作台
powershell.exe -NoProfile -ExecutionPolicy Bypass -File scripts/setup-desktop.ps1 -Auth Anonymous -ConfigureCodex -Launch
```

安装脚本会依次完成：

1. 按[固定发布描述](integrations/desktop-release.json)下载**与当前仓库版本匹配**的安装器；同时核对仓库内SHA256与随包校验文件，失败立即停止。
2. 安装到当前用户目录。安装器随附Python后台、所需库、编译好的网页、桌面程序及WebView2离线安装程序；日常使用**不用另装Python、Node.js、Rust或ESP-IDF**。
3. 已安装同版本时直接复用。需要升级且程序仍运行时明确报错，先按正常流程退出，不强杀进程、不删除原始记录。
4. 读取已有桌面数据目录，生成包含本机绝对路径的MCP配置；安装完整配套Skill，更新已有副本前备份。
5. 启动随附MCP执行`initialize`和`ping`，核对版本与工具清单。此自检不连接硬件，也不改变输出。
6. 使用`-ConfigureCodex`时，通过官方`codex mcp add`登记`mcutool`并回读检查；更新前备份Codex配置，其他MCP服务保持。`-Launch`打开桌面窗口。

Codex CLI未在PATH中时，AI应定位已安装客户端的`codex.exe`，通过`-CodexCommand "完整路径"`指定。MCP配置变更后，按客户端要求重新加载工具或开始新会话，再实际调用`ping`确认已可见；不能把“配置文件写完”当作当前AI已能操作。

**其他AI客户端**使用同一个安装入口，省略`-ConfigureCodex`：

```powershell
powershell.exe -NoProfile -ExecutionPolicy Bypass -File scripts/setup-desktop.ps1 -Auth Anonymous -Launch
```

脚本输出桌面程序、数据目录、Skill和`mcp-config.json`的实际位置。AI将其中`mcutool`条目合并到该客户端支持的MCP配置，保留已有服务；手动配置格式见[安装版MCP示例](integrations/mcp.desktop.example.json)。Skill提供使用规则，MCP提供实际执行接口，两者都要接好。

### 下载权限与离线安装

默认`-Auth Git`使用Git已有的GitHub凭据，不打印或保存令牌。使用SSH克隆但没有HTTPS凭据时，可明确选择`-Auth Token`，由环境变量`GH_TOKEN`提供有仓库读取权限的令牌；不要把令牌放进命令参数或聊天。公开访问才使用`-Auth Anonymous`。下载失败不会自动换源或改装其他版本。

已从Release下载安装器和同名`.sha256`文件时，两者放在同一目录：

```powershell
powershell.exe -NoProfile -ExecutionPolicy Bypass -File scripts/setup-desktop.ps1 -PackageDirectory "D:\Downloads\MCUTOOL" -ConfigureCodex -Launch
```

`-DownloadOnly`仅下载并校验。需要自定义安装位置可传`-InstallDirectory`；脚本输出和生成的MCP配置会使用该实际位置。

### 安装后在哪里

| 内容 | 默认位置／规则 |
| --- | --- |
| 桌面程序 | `%LOCALAPPDATA%/MCU TOOL/mcutool-desktop.exe`，同时创建快捷方式 |
| MCP程序 | 同安装目录下`runtime/MCUTOOL-service/MCUTOOL-service.exe` |
| 数据与原始记录 | `%LOCALAPPDATA%/MCU_TOOL/data/`；存在`desktop.json`时沿用其`data_dir` |
| 桌面配置 | `%LOCALAPPDATA%/MCU_TOOL/desktop.json` |
| 接入配置、下载与备份 | `%LOCALAPPDATA%/MCU_TOOL/setup/` |
| Codex Skill | 新安装使用`~/.agents/skills/xhh-mcu-tool/`；已有`~/.codex/skills/`同名副本时原地更新 |

桌面与MCP必须使用**同一数据目录**。本开发机的绝对路径不适用于其他电脑，安装脚本会按目标电脑生成配置。

## AI如何操作工具

安装后先读[配套Skill](integrations/skill/xhh-mcu-tool/SKILL.md)，按具体任务读取[操作参数与异常处理](integrations/skill/xhh-mcu-tool/references/operations.md)或[测量与区间分析](integrations/skill/xhh-mcu-tool/references/measurements.md)。工具名以当前客户端显示的命名空间和schema为准。

| 步骤 | 接口与完成依据 |
| --- | --- |
| 确认入口 | `ping()`、`runtime_status()`核对版本和现有后台 |
| 连接工具板 | 桌面已连接时`connect()`复用。未连接时枚举端口，按用户指定的USB端口或Wi-Fi地址连接，核对`device_id`和`boot_id`；不选“第一个候选设备” |
| 只读观察 | `device_status()`看最新值和质量；`read_data(kind="measurements", after=上次next, limit=...)`持续读取，无需操作权 |
| 执行已授权操作 | `claim_control()`取得操作权，为每次写操作生成独立UUID `request_id`，再调用对应接口 |
| 核对结果 | 用`job_status(request_id)`查任务终态，结合读数或串口判断被测设备响应。超时不代表未执行，结果未知时查询证据，不重发动作 |
| 收尾 | 按测试意图结束自己开启的记录、释放自己的操作权并`detach()`；普通退出不调用会影响所有客户端的`disconnect()` |

例如用户已授权“按K1十次，每秒一次，每次按下100ms，同时记录电流变化”：

```text
recording(action="start")                         # 已连接且持有操作权
press_keys(keys=[1], press_ms=100, release_ms=900,
           count=10, request_id="本次新生成的UUID")
read_data(kind="measurements", after=测量游标)     # 循环增量读取并保存next
job_status(request_id="同一个UUID")                # 查询到终态
recording(action="stop")                          # 核对completed及文件位置
```

按键序列由工具板计时；执行期间后台继续采集和记录，AI可以交替查询任务与新增数据。测量、串口、事件各用自己的游标，检查`lost`及设备启动变化。不要用AI调用之间的等待实现按下/释放的精确定时；同一功能忙碌时不会自动排队新动作。

常用操作：`press_keys`单击/长按/连击/多键组合、`run_key_sequence`有限按键序列、`cancel_keys`取消指定动作、`power_select`选择供电通路、`charge_set`充电通路、`uart_configure`/`uart_tx`/`uart_write`串口交互。已有其他操作者时需明确交接，不能擅自抢占。一次授权的完整流程内无需逐个按键重复询问。

测量原始电流单位是**A**，图表显示为**mA**；电量是指定区间的带符号积分，单位**mAh**，不是电池剩余容量。六路10Hz不等于严格同时采样，不能拿来保证捕获瞬时尖峰。波形暂停/清空只作用于对应图表；要长期保存，提前开启后台持续记录。完整边界见Skill。

## 工具板与运行条件

桌面安装不会烧录工具板。固定 10 Hz 采样需要固件 0.1.2 或以上，板上充电循环需要固件 0.1.3 或以上，三路组合时序需要固件 0.1.4 或以上并声明相应能力。连接后在“设备设置”或设备信息里核对。需要升级时使用 Release 的固件包及[固件下载说明](docs/软件使用说明.md#2-工具固件)，先确认目标工具身份、实际接线和重启时机。重启会关闭主供电、充电、按键输出并使 TX 高阻。

工具USB与工具DC供电人工二选一。按键触点目标≤6V/20mA；UART为3.3V；主通路目标2.8～12V、双向3A；四路电压输入0～15V。`power_select`只选通路，不调外部电源电压。本工具不承担目标MCU烧录/SWD调试。实装INA226的步进、校准与精度限制见[实板测量说明](docs/INA226实板启动与测量限制.md)。

## 软件资料与开发

- [桌面版使用说明](docs/桌面版使用说明.md)：窗口、托盘、共享后台、升级和卸载。
- [图表说明](docs/上位机界面与图表使用说明.md)、[完整软件说明](docs/软件使用说明.md)、[0.4.1验证报告](docs/固定10Hz与长时间波形验证报告.md)。
- `firmware/`为ESP-IDF固件，`host/`为共享后台与MCP，`web/`为Vue网页，`desktop/`为Tauri桌面，`protocol/`为设备契约。
- **只有修改源码才需要开发工具链**：Python 3.11、Node.js 22、PowerShell 7；桌面构建另需Rust和VS C++工具，固件构建需ESP-IDF。准备后运行`scripts/install.ps1`，验证用`scripts/verify.ps1`。普通安装使用前述`setup-desktop.ps1`。
- `release/`是开发机生成产物，不随Git克隆。其他电脑从GitHub Release下载，不依赖本机的`release/latest-desktop.json`。

Codex配置方式参考[官方MCP文档](https://developers.openai.com/codex/mcp/)与[官方Skill文档](https://developers.openai.com/codex/skills/)。

## 当前工程与版本

- 当前编辑的主工程已于2026-11-12切换为嘉立创EDA专业版全在线模式的云端`AI_TOOL`；官方CLI读取、DRC、截图及导出已实测，见[云端操作记录](docs/嘉立创云端AI_TOOL操作实测.md)。
- `D:\LCEDA\projects\AI_TOOL\AI_TOOL.eprj3`及[已保存的原生工程目录](hardware/easyeda-local/project/AI_TOOL/)保留为切换前本地保存点，不与云端自动同步；当前云端工程标识见[接入信息](hardware/easyeda-cloud/connection.json)。
- [最新保存点](hardware/easyeda-local/latest-version.json)及[完整版本归档](hardware/versions/版本记录.md)：包含源文件SHA256、完整目录快照和官方工程导出。
- [装配资料](hardware/easyeda-local/assembly/2026-11-10/)：140颗器件、37种采购物料；[物料统一记录](docs/已回板物料统一修改记录.md)。
- [按键光继电器选型调查](docs/按键光继电器替代料手册核验.md)：当前工程仍使用GAQY221S/C7435105，候选料和TLP187尚未替换。

PCB已回板，当前仍需完成样机装配及性能实测。最近一次原生PCB DRC为零；原理图保留Q1～Q5/Q14六处旧焊盘本地映射的库匹配提示，详见物料统一记录。保存版本不等于重新进行电气或硬件验证。

## 资料入口

- [功能规格](.scratch/mcu-assistant/spec.md)、[需求记录](docs/MCU开发辅助工具需求记录.md)、[硬件方案](docs/MCU开发辅助工具硬件方案.md)。
- [本地工程说明](docs/嘉立创本地工程说明.md)与[领域术语](GLOSSARY.md)。
- `hardware/kicad/`及`hardware/easyeda-pro/`保留较早阶段的对比设计，当前装配以本地嘉立创主工程和本批BOM为准。

恢复时将版本归档解压到独立目录，再打开其中`AI_TOOL/AI_TOOL.eprj3`；也可导入归档附带的官方`.epro2`工程。保留完整`sch`、`pcb`、`panel`及工程配置，不能只复制单个索引文件。

## KiCad design hardware/kicad/AI_MCUTOOL.kicad_pcb

File hardware/kicad/README.md:

# KiCad 硬件工程

2026-10-24 PCB布局初稿：已建立[可编辑PCB](AI_MCUTOOL.kicad_pcb)，90×90mm、四层、164颗器件；包含完整网络及原理图关联，尚未布线。查看[布局预览PNG](preview/PCB布局初稿.png)、[可放大SVG](preview/PCB布局初稿.svg)及[布局说明](../../docs/PCB布局初稿说明.md)。华秋CLI布局违规0、原理图一致性问题0；仍有336项未连接，不能直接投板。板框、天线伸出和外壳净空还需共同收敛到100mm整机上限。

2026-10-24：按功能电路重新绘制，使用本机 KiCad 10.0.6 完成解析、网表导出、ERC、BOM 和 PDF 导出。当前为原理图审阅版，封装和样机能力尚未定版。

2026-10-24封装修复：已校正6个迁移封装的Y轴方向，MOS的Courtyard改为3.8×4.15mm；MOS和VOM补充已核本体轮廓，迁移封装补充1脚标记。新增独立几何检查，旧镜像封装会被拒绝。[修复预览](preview/封装修复预览.png)及 [几何检查结果](verification/footprint-geometry.json)可直接查看。原理图连接与图面没有重画，因此此次变化主要在封装编辑器中查看。

2026-10-24继续核定：SHUNT4按Vishay推荐图修正两个感测铜盘为1.70×0.76mm，外侧与大电流铜盘齐平，并增加本体轮廓和尺寸校验，见[核定依据](../../docs/四端分流器封装尺寸核定.md)。新增[PCB导入准备检查](verification/pcb-import.json)，通过华秋原生pcbnew逐器件载入实际封装，比较全部编号铜盘与网表脚号；尚未创建PCB。

J2已绑定项目专用 `USB_C_HRO_TYPE_C_31_M_12`，按HRO 2020-12-08 Rev A图重建12个电气铜盘、4个外壳金属化槽孔和2个定位孔，保持原理图连接。封装的Dwgs.User板边线为布局参考，不是实际板框。见[连接器核定](../../docs/电源连接器封装核定.md)和[铜盘预览](preview/连接器与分流器核定.png)。采购必须匹配已核图版。

J1已选定华秋商城常见国产件XKB `DC-005-5A-2.0`，绑定项目专用 `DC_XKB_DC005_5A_2_0`。按厂家Rev A0底视图转换为元件面坐标，1脚槽孔采用1×3.5mm；1中心正、2外套筒地、3切换NC保持原连接。合作库存页面当次单件价约1.39元，见[采购页](https://item.hqchip.com/1026633819.html)；价格及库存会变化。当前164颗器件全部绑定，已具备完整PCB导入所需的封装和引脚映射条件。

## 打开和审阅

用 KiCad 项目管理器打开 [AI_MCUTOOL.kicad_pro](AI_MCUTOOL.kicad_pro)，再打开同名原理图或PCB。保留整个目录；子图页、项目符号库和项目封装库都通过相对路径关联。

- [9 页原理图 PDF](AI_MCUTOOL-原理图.pdf)：总览及八个功能页。
- [逐器件 BOM](AI_MCUTOOL-BOM.csv)：制造商料号与封装状态分别保留。
- [校验报告](verification/check.json)、[KiCad ERC](verification/erc.json)、[独立 XML 网表](verification/netlist.xml)。
- [SVG 预览目录](preview/)：矢量图可放大查看。
- 华秋封装编辑器中打开项目库 `AI_MCUTOOL`，重点查看 `N_FET`、`P_FET`、`PHOTO_PV`；已打开的旧封装视图需要重新载入库文件。

原理图包含可编辑的器件、导线、接点、网络标签和明确的 NC 标记。标准符号已复制到项目局部库；标准封装通过 KiCad 10 自带库查找，专用封装在 `AI_MCUTOOL.pretty`。

2026-10-24后续核验：用户已在客户端打开工程，辅助功能层次树确认总览及八个功能图页均已载入；通过当前华秋gRPC运行时读取的实时整板网表也与已确认电路一致，见 [实时校验报告](verification/live-runtime-check.json)及 [接口连接核验](../../docs/KiCad接口连接核验.md)。桌面截图仍然超时，未验证鼠标操作或交互编辑后重存。CLI实际解析与导出、PDF逐页检查已经完成。

## 图页与绘图约定

| 页码 | 内容 |
| --- | --- |
| 1 | 系统总览与图页索引 |
| 2 | 工具 5V 双入口隔离及 3.3V LDO |
| 3 | ESP32-S3-WROOM-1-N16R8、复位、启动、下载及总线 |
| 4 | 五套完整按键模拟电路 |
| 5 | 真实电池与外部电源的两套背靠背 N-MOS 开关 |
| 6 | 独立充电器输入及背靠背 P-MOS 开关 |
| 7 | 四端分流、INA228 和 Kelvin 采样 |
| 8 | 四路高阻分压、缓冲、ADC 及负轨电荷泵 |
| 9 | 3.3V UART、独立 TX 高阻控制及持续 RX |

器件引脚和导线使用 1.27mm 网格；信号优先从左到右，同一功能电路直接连线。跨页接口使用全局标签，四路 ADC 的同页连接使用局部标签。重复通道保持同样布局，位号和值水平阅读，电源和地使用统一图形，未使用引脚明确标 NC。

U14 使用四个运放单元和一个电源单元，BOM 仍为一颗。MOS 堆叠引脚隐藏重复图形但保留实际脚号；N-MOS 的 9 脚属于 D，P-MOS 的 9 脚属于 S。LDO 散热片用库脚号 4，与输出脚 2 同网。

KiCad 的公开文本格式、标准库和命令行检查便于自动化，但不会自动保证图面可读或电路正确。本工程同时检查布局、ERC 和原方案连接等价性。

## 实际校验结果

| 项目 | 结果 |
| --- | --- |
| 实体器件 / BOM 数量 | 164 / 164 |
| 实体符号单元 | 168，含 U14 的 5 个单元 |
| 物理引脚 | 508，全部存在且无重复归网 |
| 连接引脚 / 网络 | 484 / 124 |
| NC 引脚 | 24，集合及网表 NC 标记一致 |
| 与原连接依据逐网络端点集合比较 | 0 差异 |
| ERC | 0 错误、0 警告、0 排除违规 |
| 已绑定封装的脚号覆盖 | 164 颗全部覆盖，华秋原生pcbnew加载及铜盘映射通过 |
| 未绑定封装 | 0 |

连接回归依据为本目录的 `connectivity-baseline.json`。原嘉立创源数据目录已缺失，该文件从修复前通过审查的 `verification/check.json` 网络端点及原XML的NC集合恢复，保留原binding哈希及原理图哈希；不会根据当前输出自动改写基准。验证脚本读取华秋KiCad独立导出的XML，并执行封装几何检查。

ERC 使用 KiCad 默认启用规则，没有添加违规排除。KiCad 默认忽略的 `single_global_label`、`four_way_junction`、`simulation_model_issue`、`footprint_filter` 如实保留在报告中；`--severity-all` 不等于启用这些默认关闭的规则。

### LM66100 专用符号模型

沿用已核方案：U1/U2 的 ST 固定接地，NC 接地，CE 接本路 VOUT。依据见 [五伏双入口隔离器件核验](../../docs/五伏双入口隔离器件核验.md)，TI 允许未使用的 ST 接地。

项目符号将 ST 命名为 `ST_GND`、类型设为 passive；生成器强制检查 5 脚必须接 `COMMON_GND`。该符号只适用于本项目固定接地方式，不能直接复用作状态输出。VOUT 为理想二极管汇合端，使用 passive，并在输入电源及汇合节点放置 PWR_FLAG 声明供电。这些模型处理避免将合法的 ST 接地和理想二极管汇合误判为输出端冲突，没有改变实物连接。

## 后续工程边界

J1/J2均使用已核图版的专用封装，没有套用本机尺寸不同的通用标准库。迁移封装的编号方向已修正，钢网和实际采购型号仍需制造审查。[封装来源记录](footprint-provenance.json)、固定的 `footprint-source.json`、`typec-footprint-source.json` 及 `dc-footprint-source.json` 保留恢复依据、厂家尺寸与来源哈希；四端分流器保持WSK2512R0200BEA、20mΩ、0.1%，其四个铜盘已按厂家第2页对应阻值档核定并修正。来源JSON通过独立manufacturerReview字段记录此次厂家图修订，不从输出封装反向更新。

用户授权开始后，已采用90×90mm、四层板制作可调整布局初稿，外壳及固定孔尚未定版。`pcb-import.json` 的 `readyForCompleteImport` 为true；[PCB实际检查](verification/pcb-layout-check.json)进一步核对了164颗器件、508个逻辑端子、520个有编号铜盘、四铜层及天线禁布规则。布局和原理图一致性检查通过，尚未布线。

LDO散热与反流、MOS动作及互锁、测量精度和校准仍需布线与样机验证。当前没有制造文件，不能据此直接投板；U4项目封装仅将跨主板边缘的丝印轮廓移到Fab，保留标准铜盘、接地孔及全层天线禁布区。

## 维护与复现

日常可直接在华秋KiCad编辑。当前可独立运行封装重建和检查；整个原理图的历史生成器仍引用已缺失的嘉立创数据，暂不可复现整图重建。不要通过运行历史生成器覆盖GUI修改。工程ZIP用于直接打开审阅，维护脚本在仓库 `hardware/tools/` 中运行。

PCB可直接在编辑器内调整。`build_pcb_layout.py`默认拒绝覆盖现有文件，只有显式`--replace-draft`且哈希仍与自动生成结果一致时才能重建；修改过的GUI布局会受到保护。PCB检查使用`kicad-cli pcb drc --schematic-parity`和`hardware/tools/verify_pcb_layout.py`，完整命令见布局说明。

在仓库根目录执行检查，不会重新绘图：

```powershell
& 'D:\Application\kicad\install\bin\python.exe' hardware/tools/verify_kicad_schematic.py
& 'D:\Application\kicad\install\bin\python.exe' hardware/tools/verify_pcb_import.py
```

只重建封装并核对，命令不会重画原理图：

```powershell
& 'D:\Application\kicad\install\bin\python.exe' hardware/tools/kicad_project_footprints.py
& 'D:\Application\kicad\install\bin\python.exe' hardware/tools/verify_kicad_footprints.py --output hardware/kicad/verification/footprint-geometry.json
& 'D:\Application\kicad\install\bin\python.exe' hardware/tools/verify_kicad_schematic.py
```

历史布局与线路在 `../tools/kicad_circuit_pages.py`；封装生成在 `../tools/kicad_project_footprints.py`，独立几何检查在 `../tools/verify_kicad_footprints.py`。未来授权改电路时，回归依据应随经过审查的设计更新，不能忽略差异或自动接受新网表。

Notes on the sheet:
KEY1～KEY5独立无极性触点 TLP176AM + MMBT3904 按键边界：≤6V、≤20mA 触点侧不接工具公共地
BAT_IN / EXT_IN → VSEL_P VOM1271T隔离栅极驱动 共源背靠背N-MOS 两路互斥、先断后通
DUT_UART：3.3V TTL TX三态缓冲，默认高阻 RX施密特缓冲，持续接收 TX / RX / GND三针接口
AI-MCUTOOL / ESP32-S3-WROOM-1-N16R8 Wi-Fi控制 · 五路按键 · 电源切换 · 充电插拔 · 电池测量 · 四路电压 · 3.3V UART
CHG_IN → DUT_CHG 独立5V充电器输入 共源背靠背P-MOS 无主动放电；真实电池模式验证
外部电池 / 模拟电源 / 充电器各自独立；工具自身仅使用5V供电。 双击功能框进入图页。跨页接口使用命名端口；同页功能电路优先直接连线。 当前为原理图设计，未做PCB、样机或整机额定能力验收。
DC / Type-C：仅5V LM66100双入口隔离 LDL1117输出3.3V 输出：TOOL_3V3 / COMMON_GND
VSEL_P → DUT_PWR 20mΩ四端分流 + INA228 电池端双向电流 / 接口电压 I2C + CURRENT_ALERT
ESP32-S3-WROOM-1-N16R8 Wi-Fi控制与共享I2C RESET / BOOT / CONFIG 独立下载口和状态指示
AIN1～AIN4：共地0～15V 高阻分压 → OPA4391 → ADS1115 LM7705提供近零测量负轨 四路分别校准；I2C读取

Parts:
C26, C27: 100nF; C_0603_1608Metric; Manufacturer Part GRM188R71H104KA93D
J18: DUT_UART; PinHeader_1x03_P2.54mm_Vertical
R76: 10k; R_0603_1608Metric; Manufacturer Part RC0603FR-0710KL
R77: 100k; R_0603_1608Metric; Manufacturer Part RC0603FR-07100KL
R78: 470k; R_0603_1608Metric; Manufacturer Part RC0603FR-07470KL
R79, R80: 100; R_0603_1608Metric; Manufacturer Part RC0603FR-07100RL
U16: SN74AUP1G125; SOT-23-5; Manufacturer Part SN74AUP1G125DBVR
U17: 74LVC1G17; SOT-23-5; Manufacturer Part 74LVC1G17GV,125

Connections:
COMMON_GND: C26.2, C27.2, J18.3, R78.2, U16.3 (GND), U17.3 (GND); also elsewhere on the board
DUT_UART_RX: U17.4; also elsewhere on the board
DUT_UART_TX: R77.2, U16.2; also elsewhere on the board
unnamed: J18.1, R79.2
unnamed: J18.2, R80.1
unnamed: R78.1, R80.2, U17.2
unnamed: R79.1, U16.4
TOOL_3V3: C26.1, C27.1, R76.1, R77.1, U16.5 (VCC), U17.5 (VCC); also elsewhere on the board
UART_TX_NOE: R76.2, U16.1; also elsewhere on the board

Notes on the sheet:
08 目标UART接口
仅3.3V电平；TOOL_TX接DUT_RX，TOOL_RX接DUT_TX。接收路径持续有效，发送可独立置高阻。
TX使能低有效；10kΩ上拉保证复位时高阻。 RX使用施密特缓冲；470kΩ使悬空输入有确定电平。 两侧100Ω用于隔离、限制瞬态电流，不代表5V容限。

Parts:
C5: 22uF; C_0805_2012Metric; Manufacturer Part GRM21BR61C226ME44L
C6: 100nF; C_0603_1608Metric; Manufacturer Part GRM188R71H104KA93D
C7: 1uF; C_0603_1608Metric; Manufacturer Part GRM188R71C105KA12D
J3: 下载 / 调试 UART0; PinHeader_1x05_P2.54mm_Vertical
LED1: PWR / 红; LED_0603_1608Metric; Manufacturer Part LTST-C190KRKT
LED2: STATUS / 绿; LED_0603_1608Metric; Manufacturer Part LTST-C190KGKT
R5, R6, R7, R8, R9: 10k; R_0603_1608Metric; Manufacturer Part RC0603FR-0710KL
R10, R11: 1k; R_0603_1608Metric; Manufacturer Part RC0603FR-071KL
R81, R82: 4.7k; R_0603_1608Metric; Manufacturer Part RC0603FR-074K7L
SW1: RESET; SW4; Manufacturer Part TS-1187A-B-A-B
SW2: BOOT; SW4; Manufacturer Part TS-1187A-B-A-B
SW3: CONFIG; SW4; Manufacturer Part TS-1187A-B-A-B
U4: ESP32-S3-WROOM-1-N16R8; ESP32-S3-WROOM-1; Manufacturer Part ESP32-S3-WROOM-1-N16R8

Connections:
/02 主控与总线/ESP_BOOT: J3.4, R6.2, SW2.1, SW2.2 (1), U4.27 (IO0)
/02 主控与总线/ESP_EN: C7.1, J3.5, R5.2, SW1.1, SW1.2 (1), U4.3 (EN)
/02 主控与总线/STATUS_LED: R11.1, U4.9 (IO16)
/02 主控与总线/UART0_RX: J3.2, U4.36 (RXD0)
/02 主控与总线/UART0_TX: J3.1, U4.37 (TXD0)
BAT_PATH_EN: U4.19 (IO11); also elsewhere on the board
CHARGE_PATH_EN: U4.21 (IO13); also elsewhere on the board
COMMON_GND: C5.2, C6.2, C7.2, J3.3, LED1.1 (K), LED2.1 (K), R7.2, R8.2, SW1.3 (2), SW1.4 (2), SW2.3 (2), SW2.4 (2), SW3.3 (2), SW3.4 (2), U4.1 (GND), U4.40 (GND), U4.41 (GND); also elsewhere on the board
CURRENT_ALERT: U4.11 (IO18); also elsewhere on the board
DUT_UART_RX: U4.8 (IO15); also elsewhere on the board
DUT_UART_TX: U4.22 (IO14); also elsewhere on the board
EXT_PATH_EN: U4.20 (IO12); also elsewhere on the board
I2C_SCL: R82.2, U4.18 (IO10); also elsewhere on the board
I2C_SDA: R81.2, U4.17 (IO9); also elsewhere on the board
KEY1_CTRL: U4.4 (IO4); also elsewhere on the board
KEY2_CTRL: U4.5 (IO5); also elsewhere on the board
KEY3_CTRL: U4.6 (IO6); also elsewhere on the board
KEY4_CTRL: U4.7 (IO7); also elsewhere on the board
KEY5_CTRL: U4.12 (IO8); also elsewhere on the board
unnamed: LED1.2 (A), R10.2
unnamed: LED2.2 (A), R11.2
unnamed: R8.1, U4.15 (IO3)
unnamed: R9.2, SW3.1, SW3.2 (1), U4.10 (IO17)
unnamed: R7.1, U4.16 (IO46)
TOOL_3V3: C5.1, C6.1, R5.1, R6.1, R9.1, R10.1, R81.1, R82.1, U4.2 (3V3); also elsewhere on the board
UART_TX_NOE: U4.31 (IO38); also elsewhere on the board

Notes on the sheet:
DOWNLOAD针序：TX0、RX0、GND、BOOT、EN。 下载口不参与工具供电；3.3V UART电平。
共享I2C：仅一组上拉
ESP32-S3-WROOM-1-N16R8模组；GPIO35/36/37被PSRAM占用，禁止用于业务接口。
复位 / 启动
各电源通路与按键驱动的默认关闭由外部偏置保证。 连接器方向、天线净空、LDO热源距离在PCB阶段复核。
02 主控与总线

Parts:
C10, C11, C12, C13, C14, C15, C16, C17: 10nF; C_0603_1608Metric; Manufacturer Part GRM1885C1H103JA01D
C18, C19, C20, C24, C25: 100nF; C_0603_1608Metric; Manufacturer Part GRM188R71H104KA93D
C21: 10uF; C_0805_2012Metric; Manufacturer Part GRM21BR61C106KE15L
C22, C23: 22uF; C_0805_2012Metric; Manufacturer Part GRM21BR61C226ME44L
J14: AIN1; PinHeader_1x02_P2.54mm_Vertical
J15: AIN2; PinHeader_1x02_P2.54mm_Vertical
J16: AIN3; PinHeader_1x02_P2.54mm_Vertical
J17: AIN4; PinHeader_1x02_P2.54mm_Vertical
R40, R41, R42, R43, R44, R49, R50, R51, R52, R53, R58, R59, R60, R61, R62, R67, R68, R69, R70, R71: 2M; R_1206_3216Metric; Manufacturer Part TNPW12062M00BEEA
R45, R54, R63, R72: 1M; R_0805_2012Metric; Manufacturer Part TNPW08051M00BEEA
R46, R55, R64, R73: 499 / 0.1%; R_0603_1608Metric; Manufacturer Part TNPW0603499RBEEA
R47, R56, R65, R74: 100k / 0.1%; R_0603_1608Metric; Manufacturer Part TNPW0603100KBEEA
R48, R57, R66, R75: 100; R_0603_1608Metric; Manufacturer Part RC0603FR-07100RL
U13: ADS1115IDGSR; TSSOP-10_3x3mm_P0.5mm; Manufacturer Part ADS1115IDGSR
U14: OPA4391; TSSOP-14_4.4x5mm_P0.65mm; Manufacturer Part OPA4391PWR
U15: LM7705; VSSOP-8_3x3mm_P0.65mm; Manufacturer Part LM7705MM/NOPB

Connections:
/07 四路高阻电压检测/ADC_CH1: C11.1, R48.2, U13.4 (AIN0)
/07 四路高阻电压检测/ADC_CH2: C13.1, R57.2, U13.5 (AIN1)
/07 四路高阻电压检测/ADC_CH3: C15.1, R66.2, U13.6 (AIN2)
/07 四路高阻电压检测/ADC_CH4: C17.1, R75.2, U13.7 (AIN3)
COMMON_GND: C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C20.2, C22.2, C23.2, C24.2, C25.2, J14.2, J15.2, J16.2, J17.2, R45.2, R54.2, R63.2, R72.2, U13.1 (ADDR), U13.3 (GND), U15.2 (GND), U15.3 (SD), U15.5 (GND); also elsewhere on the board
I2C_SCL: U13.10 (SCL); also elsewhere on the board
I2C_SDA: U13.9 (SDA); also elsewhere on the board
unnamed: J14.1, R40.1
unnamed: J15.1, R49.1
unnamed: J16.1, R58.1
unnamed: J17.1, R67.1
unnamed: R40.2, R41.1
unnamed: R41.2, R42.1
unnamed: R42.2, R43.1
unnamed: R43.2, R44.1
unnamed: R46.1, R48.1, U14.1
unnamed: R49.2, R50.1
unnamed: R50.2, R51.1
unnamed: R51.2, R52.1
unnamed: R52.2, R53.1
unnamed: R55.1, R57.1, U14.7
unnamed: R58.2, R59.1
unnamed: R59.2, R60.1
unnamed: R60.2, R61.1
unnamed: R61.2, R62.1
unnamed: R64.1, R66.1, U14.8
unnamed: R67.2, R68.1
unnamed: R68.2, R69.1
unnamed: R69.2, R70.1
unnamed: R70.2, R71.1
unnamed: R73.1, R75.1, U14.14
unnamed: C10.1, R44.2, R45.1, U14.3 (+)
unnamed: R46.2, R47.1, U14.2 (-)
unnamed: C12.1, R53.2, R54.1, U14.5 (+)
unnamed: R55.2, R56.1, U14.6 (-)
unnamed: C14.1, R62.2, R63.1, U14.10 (+)
unnamed: R64.2, R65.1, U14.9 (-)
unnamed: C16.1, R71.2, R72.1, U14.12 (+)
unnamed: R73.2, R74.1, U14.13 (-)
unnamed: C21.1, U15.1 (CF+)
unnamed: C21.2, U15.8 (CF-)
unnamed: C22.1, U15.7 (CRES)
TOOL_3V3: C18.1, C19.1, C20.1, C25.1, U13.8 (VDD), U14.4 (V+), U15.4 (VDD); also elsewhere on the board
VNEG: C19.2, C23.1, C24.1, R47.2, R56.2, R65.2, R74.2, U14.11 (V-), U15.6 (VOUT)

Notes on the sheet:
四路0～15V输入、各自AIN/GND；每路5×2MΩ串联 + 1MΩ下拉。负压输入不支持。
ADC_CH1～4：同页缓冲输出到ADC的测量接口。 分压精度、近零偏置、PCB清洁与漏电共同决定误差。
高阻节点不可随意增加泄漏较大的保护元件； 负轨及前端近零误差须标定与样机验证。
07 四路高阻电压检测
