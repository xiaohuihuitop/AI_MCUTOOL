# Repository xiaohuihuitop/AI_MCUTOOL (continued)

## KiCad design hardware/kicad/AI_MCUTOOL.kicad_pcb (continued)

Parts:
J4: KEY1; PinHeader_1x02_P2.54mm_Vertical
J5: KEY2; PinHeader_1x02_P2.54mm_Vertical
J6: KEY3; PinHeader_1x02_P2.54mm_Vertical
J7: KEY4; PinHeader_1x02_P2.54mm_Vertical
J8: KEY5; PinHeader_1x02_P2.54mm_Vertical
Q1, Q2, Q3, Q4, Q5: MMBT3904; SOT-23; Manufacturer Part MMBT3904LT1G
R12, R15, R18, R21, R24: 240; R_0603_1608Metric; Manufacturer Part RC0603FR-07240RL
R13, R16, R19, R22, R25: 680; R_0603_1608Metric; Manufacturer Part RC0603FR-07680RL
R14, R17, R20, R23, R26: 10k; R_0603_1608Metric; Manufacturer Part RC0603FR-0710KL
U5, U6, U7, U8, U9: TLP176AM; PHOTO_MOS; Manufacturer Part TLP176AM(TPL,E

Connections:
COMMON_GND: Q1.2 (E), Q2.2 (E), Q3.2 (E), Q4.2 (E), Q5.2 (E), R14.2, R17.2, R20.2, R23.2, R26.2; also elsewhere on the board
KEY1_CTRL: R13.1; also elsewhere on the board
KEY2_CTRL: R16.1; also elsewhere on the board
KEY3_CTRL: R19.1; also elsewhere on the board
KEY4_CTRL: R22.1; also elsewhere on the board
KEY5_CTRL: R25.1; also elsewhere on the board
unnamed: Q1.1 (B), R13.2, R14.1
unnamed: Q1.3 (C), U5.3 (K)
unnamed: Q2.1 (B), R16.2, R17.1
unnamed: Q2.3 (C), U6.3 (K)
unnamed: Q3.1 (B), R19.2, R20.1
unnamed: Q3.3 (C), U7.3 (K)
unnamed: Q4.1 (B), R22.2, R23.1
unnamed: Q4.3 (C), U8.3 (K)
unnamed: Q5.1 (B), R25.2, R26.1
unnamed: Q5.3 (C), U9.3 (K)
unnamed: R12.2, U5.1 (A)
unnamed: J4.1, U5.4 (CONTACT_A)
unnamed: J4.2, U5.6 (CONTACT_B)
unnamed: R15.2, U6.1 (A)
unnamed: J5.1, U6.4 (CONTACT_A)
unnamed: J5.2, U6.6 (CONTACT_B)
unnamed: R18.2, U7.1 (A)
unnamed: J6.1, U7.4 (CONTACT_A)
unnamed: J6.2, U7.6 (CONTACT_B)
unnamed: R21.2, U8.1 (A)
unnamed: J7.1, U8.4 (CONTACT_A)
unnamed: J7.2, U8.6 (CONTACT_B)
unnamed: R24.2, U9.1 (A)
unnamed: J8.1, U9.4 (CONTACT_A)
unnamed: J8.2, U9.6 (CONTACT_B)
TOOL_3V3: R12.1, R15.1, R18.1, R21.1, R24.1; also elsewhere on the board

Notes on the sheet:
KEY4
KEY1
KEY3
03 五路按键模拟
KEY5
触点独立、无极性；被测按键≤6V、≤20mA。触点不接工具公共地。
240Ω为PhotoMOS LED限流；680Ω为基极电阻；10kΩ保证控制悬空时关闭。
KEY2

Parts:
C8, C9: 100nF; C_0603_1608Metric; Manufacturer Part GRM188R71H104KA93D
J11: DUT_PWR; PinHeader_1x02_P2.54mm_Vertical
R37, R38: 10; R_0603_1608Metric; Manufacturer Part RC0603FR-0710RL
R39: 10k; R_0603_1608Metric; Manufacturer Part RC0603FR-0710KL
RSH1: 20mΩ / 0.1% / 4端; SHUNT4; Manufacturer Part WSK2512R0200BEA
U12: INA228AIDGSR; TSSOP-10_3x3mm_P0.5mm; Manufacturer Part INA228AIDGSR

Connections:
COMMON_GND: C9.2, J11.2, U12.1 (A1), U12.2 (A0), U12.7 (GND); also elsewhere on the board
CURRENT_ALERT: R39.2, U12.3 (~Alert); also elsewhere on the board
I2C_SCL: U12.5 (SCL); also elsewhere on the board
I2C_SDA: U12.4 (SDA); also elsewhere on the board
unnamed: R37.1, RSH1.3 (E1)
unnamed: R38.1, RSH1.2 (E2)
unnamed: J11.1, RSH1.1 (I2), U12.8 (Vbus)
unnamed: C8.1, R37.2, U12.10 (Vin+)
unnamed: C8.2, R38.2, U12.9 (Vin-)
TOOL_3V3: C9.1, R39.1, U12.6 (VS); also elsewhere on the board
VSEL_P: RSH1.4 (I1); also elsewhere on the board

Notes on the sheet:
I2C地址：A1=A0=GND。 10Ω + 100nF为差分输入滤波；采样线成对靠近，远离大电流回路。 输出为电池端总电流与DUT_PWR接口电压，合格判定由被测项目定义。
06 电池端电流与电压
双向电流测量；I1/I2为载流端，E1/E2为Kelvin采样端，PCB上不得提前短接。

Parts:
J12: CHG_IN / 5V; PinHeader_1x02_P2.54mm_Vertical
J13: DUT_CHG; PinHeader_1x02_P2.54mm_Vertical
Q12, Q13: CSD25402Q3A; P_FET; Manufacturer Part CSD25402Q3A
Q14: MMBT3904; SOT-23; Manufacturer Part MMBT3904LT1G
R33, R36: 10k; R_0603_1608Metric; Manufacturer Part RC0603FR-0710KL
R34: 100; R_0603_1608Metric; Manufacturer Part RC0603FR-07100RL
R35: 4.7k; R_0603_1608Metric; Manufacturer Part RC0603FR-074K7L

Connections:
CHARGE_PATH_EN: R35.1; also elsewhere on the board
COMMON_GND: J12.2, J13.2, Q14.2 (E), R36.2; also elsewhere on the board
unnamed: J12.1, Q12.1 (D), Q12.2 (D), Q12.3 (D)
unnamed: J13.1, Q13.1 (D), Q13.2 (D), Q13.3 (D)
unnamed: Q12.4 (G), Q13.4 (G), R33.1, R34.1
unnamed: Q12.5 (S), Q12.6 (S), Q12.7 (S), Q12.8 (S), Q12.9 (S), Q13.5 (S), Q13.6 (S), Q13.7 (S), Q13.8 (S), Q13.9 (S), R33.2
unnamed: Q14.1 (B), R35.2, R36.1
unnamed: Q14.3 (C), R34.2

Notes on the sheet:
共源P-MOS：5～9脚为S；1～3脚为D；4脚为G。 R33把G拉回共源点，控制悬空时关闭。 不增加主动放电；关闭后DUT端电压的下降由实际负载决定。
05 独立充电输入
独立外接5V充电器；验证充电时选择真实电池。充电输入与工具自身5V正端分开。

Parts:
C1, C2: 1uF; C_0603_1608Metric; Manufacturer Part GRM188R71C105KA12D
C3, C4: 4.7uF; C_0805_2012Metric; Manufacturer Part GRM21BR71C475KA73L
J1: DC 5V / 中心正; DC_XKB_DC005_5A_2_0; Manufacturer Part DC-005-5A-2.0
J2: USB-C / 仅5V; USB_C_HRO_TYPE_C_31_M_12; Manufacturer Part TYPE-C-31-M-12
R1, R2: 4.7k; R_0603_1608Metric; Manufacturer Part RC0603FR-074K7L
R3, R4: 5.1k; R_0603_1608Metric; Manufacturer Part RC0603FR-075K1L
U1, U2: LM66100DCKR; SOT-363_SC-70-6; Manufacturer Part LM66100DCKR
U3: LDL1117S33R; LDL1117; Manufacturer Part LDL1117S33R

Connections:
COMMON_GND: C1.2, C2.2, C3.2, C4.2, J1.2 (-), J2.1 (GND), J2.2 (GND), J2.3 (GND), J2.4 (GND), J2.A1B12 (GND), J2.B1A12 (GND), R1.2, R2.2, R3.2, R4.2, U1.2 (GND), U1.4 (NC), U1.5 (ST_GND), U2.2 (GND), U2.4 (NC), U2.5 (ST_GND), U3.1 (GND); also elsewhere on the board
unnamed: C1.1, J1.1 (+), R1.1, U1.1 (VIN)
unnamed: J2.A5 (CC1), R3.1
unnamed: J2.B5 (CC2), R4.1
unnamed: C3.1, U1.3 (~CE), U1.6 (VOUT), U2.3 (~CE), U2.6 (VOUT), U3.3 (IN)
unnamed: C2.1, J2.A4B9 (VBUS), J2.B4A9 (VBUS), R2.1, U2.1 (VIN)
TOOL_3V3: C4.1, U3.2 (OUT), U3.4 (TAB); also elsewhere on the board

Notes on the sheet:
CE接各自输出，构成理想二极管功能；ST及NC按已核方案接地。
输入隔离
工具自身：DC / Type-C 二选一输入5V；外部电池和充电器正端不接入本页。
01 工具电源
3.3V稳压
LDO散热、输入掉电反流及实际输出电容稳定性需样机验证。 Type-C不做PD协商；CC1 / CC2各5.1kΩ下拉。

Schematic: 04_source_switch.kicad_sch, 04 主供电选择

Parts:
J9: BAT_IN; PinHeader_1x02_P2.54mm_Vertical
J10: EXT_IN; PinHeader_1x02_P2.54mm_Vertical
Q6, Q7: MMBT3904; SOT-23; Manufacturer Part MMBT3904LT1G
Q8, Q9, Q10, Q11: CSD17577Q3A; N_FET; Manufacturer Part CSD17577Q3A
R27, R30: 100 / 1206; R_1206_3216Metric; Manufacturer Part RC1206FR-07100RL
R28, R31: 330; R_0603_1608Metric; Manufacturer Part RC0603FR-07330RL
R29, R32: 10k; R_0603_1608Metric; Manufacturer Part RC0603FR-0710KL
U10, U11: VOM1271T; PHOTO_PV; Manufacturer Part VOM1271T

Connections:
BAT_PATH_EN: R28.1; also elsewhere on the board
COMMON_GND: J9.2, J10.2, Q6.2 (E), Q7.2 (E), R29.2, R32.2; also elsewhere on the board
EXT_PATH_EN: R31.1; also elsewhere on the board
unnamed: J9.1, Q8.5 (D), Q8.6 (D), Q8.7 (D), Q8.8 (D), Q8.9 (D)
unnamed: J10.1, Q10.5 (D), Q10.6 (D), Q10.7 (D), Q10.8 (D), Q10.9 (D)
unnamed: Q6.1 (B), R28.2, R29.1
unnamed: Q6.3 (C), U10.2 (K)
unnamed: Q7.1 (B), R31.2, R32.1
unnamed: Q7.3 (C), U11.2 (K)
unnamed: Q8.4 (G), Q9.4 (G), U10.4 (PV+)
unnamed: Q10.4 (G), Q11.4 (G), U11.4 (PV+)
unnamed: R27.2, U10.1 (A)
unnamed: Q8.1 (S), Q8.2 (S), Q8.3 (S), Q9.1 (S), Q9.2 (S), Q9.3 (S), U10.3 (PV-)
unnamed: R30.2, U11.1 (A)
unnamed: Q10.1 (S), Q10.2 (S), Q10.3 (S), Q11.1 (S), Q11.2 (S), Q11.3 (S), U11.3 (PV-)
TOOL_3V3: R27.1, R30.1; also elsewhere on the board
VSEL_P: Q9.5 (D), Q9.6 (D), Q9.7 (D), Q9.8 (D), Q9.9 (D), Q11.5 (D), Q11.6 (D), Q11.7 (D), Q11.8 (D), Q11.9 (D); also elsewhere on the board

Notes on the sheet:
BAT_IN与EXT_IN互斥，切换先断后通，允许被测设备断电。不得同时开启两路。
背靠背共源结构：两只N-MOS的S相连；9脚散热焊盘属于D。 光伏驱动的PV-参考共源点，PV+驱动两只MOS的G。 MOS选型、栅极建立/释放时间及双向关断仍需样机验收。
外部模拟电源
共地边界：电池、模拟电源、工具与DUT共地；高侧开关只切正端。 输出汇合后，串联四端分流器进入DUT_PWR。
真实电池
04 主供电选择

Board: 4 copper layers, 164 parts (0 on the bottom side), 124 nets, no tracks yet.

File hardware/kicad/AI_MCUTOOL-BOM.csv (part):

"位号","图纸值","制造商料号","封装","数量","封装状态"
"C1","1uF","GRM188R71C105KA12D","Capacitor_SMD:C_0603_1608Metric","1","封装几何仍需制造审查"
"C2","1uF","GRM188R71C105KA12D","Capacitor_SMD:C_0603_1608Metric","1","封装几何仍需制造审查"
"C3","4.7uF","GRM21BR71C475KA73L","Capacitor_SMD:C_0805_2012Metric","1","封装几何仍需制造审查"
"C4","4.7uF","GRM21BR71C475KA73L","Capacitor_SMD:C_0805_2012Metric","1","封装几何仍需制造审查"
"C5","22uF","GRM21BR61C226ME44L","Capacitor_SMD:C_0805_2012Metric","1","封装几何仍需制造审查"
"C6","100nF","GRM188R71H104KA93D","Capacitor_SMD:C_0603_1608Metric","1","封装几何仍需制造审查"
"C7","1uF","GRM188R71C105KA12D","Capacitor_SMD:C_0603_1608Metric","1","封装几何仍需制造审查"
"C8","100nF","GRM188R71H104KA93D","Capacitor_SMD:C_0603_1608Metric","1","封装几何仍需制造审查"
"C9","100nF","GRM188R71H104KA93D","Capacitor_SMD:C_0603_1608Metric","1","封装几何仍需制造审查"
"C10","10nF","GRM1885C1H103JA01D","Capacitor_SMD:C_0603_1608Metric","1","封装几何仍需制造审查"
"C11","10nF","GRM1885C1H103JA01D","Capacitor_SMD:C_0603_1608Metric","1","封装几何仍需制造审查"
"C12","10nF","GRM1885C1H103JA01D","Capacitor_SMD:C_0603_1608Metric","1","封装几何仍需制造审查"
"C13","10nF","GRM1885C1H103JA01D","Capacitor_SMD:C_0603_1608Metric","1","封装几何仍需制造审查"
"C14","10nF","GRM1885C1H103JA01D","Capacitor_SMD:C_0603_1608Metric","1","封装几何仍需制造审查"
"C15","10nF","GRM1885C1H103JA01D","Capacitor_SMD:C_0603_1608Metric","1","封装几何仍需制造审查"
"C16","10nF","GRM1885C1H103JA01D","Capacitor_SMD:C_0603_1608Metric","1","封装几何仍需制造审查"
"C17","10nF","GRM1885C1H103JA01D","Capacitor_SMD:C_0603_1608Metric","1","封装几何仍需制造审查"
"C18","100nF","GRM188R71H104KA93D","Capacitor_SMD:C_0603_1608Metric","1","封装几何仍需制造审查"
"C19","100nF","GRM188R71H104KA93D","Capacitor_SMD:C_0603_1608Metric","1","封装几何仍需制造审查"
"C20","100nF","GRM188R71H104KA93D","Capacitor_SMD:C_0603_1608Metric","1","封装几何仍需制造审查"
"C21","10uF","GRM21BR61C106KE15L","Capacitor_SMD:C_0805_2012Metric","1","封装几何仍需制造审查"
"C22","22uF","GRM21BR61C226ME44L","Capacitor_SMD:C_0805_2012Metric","1","封装几何仍需制造审查"
"C23","22uF","GRM21BR61C226ME44L","Capacitor_SMD:C_0805_2012Metric","1","封装几何仍需制造审查"
"C24","100nF","GRM188R71H104KA93D","Capacitor_SMD:C_0603_1608Metric","1","封装几何仍需制造审查"
"C25","100nF","GRM188R71H104KA93D","Capacitor_SMD:C_0603_1608Metric","1","封装几何仍需制造审查"
"C26","100nF","GRM188R71H104KA93D","Capacitor_SMD:C_0603_1608Metric","1","封装几何仍需制造审查"
"C27","100nF","GRM188R71H104KA93D","Capacitor_SMD:C_0603_1608Metric","1","封装几何仍需制造审查"
"J1","DC 5V / 中心正","DC-005-5A-2.0","AI_MCUTOOL:DC_XKB_DC005_5A_2_0","1","XKB Rev A0孔位与触点已核；实物插头配合及焊接待验证"
"J2","USB-C / 仅5V","TYPE-C-31-M-12","AI_MCUTOOL:USB_C_HRO_TYPE_C_31_M_12","1","HRO 2020-12-08厂家铜盘/槽孔已核；采购图版及工艺待确认"
"J3","下载 / 调试 UART0","","Connector_PinHeader_2.54mm:PinHeader_1x05_P2.54mm_Vertical","1","封装几何仍需制造审查"
"J4","KEY1","","Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical","1","封装几何仍需制造审查"
"J5","KEY2","","Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical","1","封装几何仍需制造审查"
"J6","KEY3","","Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical","1","封装几何仍需制造审查"
"J7","KEY4","","Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical","1","封装几何仍需制造审查"
"J8","KEY5","","Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical","1","封装几何仍需制造审查"
"J9","BAT_IN","","Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical","1","封装几何仍需制造审查"
"J10","EXT_IN","","Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical","1","封装几何仍需制造审查"
"J11","DUT_PWR","","Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical","1","封装几何仍需制造审查"
"J12","CHG_IN / 5V","","Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical","1","封装几何仍需制造审查"
"J13","DUT_CHG","","Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical","1","封装几何仍需制造审查"
"J14","AIN1","","Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical","1","封装几何仍需制造审查"
"J15","AIN2","","Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical","1","封装几何仍需制造审查"
"J16","AIN3","","Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical","1","封装几何仍需制造审查"
"J17","AIN4","","Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical","1","封装几何仍需制造审查"
"J18","DUT_UART","","Connector_PinHeader_2.54mm:PinHeader_1x03_P2.54mm_Vertical","1","封装几何仍需制造审查"
"LED1","PWR / 红","LTST-C190KRKT","LED_SMD:LED_0603_1608Metric","1","封装几何仍需制造审查"
"LED2","STATUS / 绿","LTST-C190KGKT","LED_SMD:LED_0603_1608Metric","1","封装几何仍需制造审查"
"Q1","MMBT3904","MMBT3904LT1G","Package_TO_SOT_SMD:SOT-23","1","封装几何仍需制造审查"
"Q2","MMBT3904","MMBT3904LT1G","Package_TO_SOT_SMD:SOT-23","1","封装几何仍需制造审查"
"Q3","MMBT3904","MMBT3904LT1G","Package_TO_SOT_SMD:SOT-23","1","封装几何仍需制造审查"
"Q4","MMBT3904","MMBT3904LT1G","Package_TO_SOT_SMD:SOT-23","1","封装几何仍需制造审查"
"Q5","MMBT3904","MMBT3904LT1G","Package_TO_SOT_SMD:SOT-23","1","封装几何仍需制造审查"
"Q6","MMBT3904","MMBT3904LT1G","Package_TO_SOT_SMD:SOT-23","1","封装几何仍需制造审查"
"Q7","MMBT3904","MMBT3904LT1G","Package_TO_SOT_SMD:SOT-23","1","封装几何仍需制造审查"
"Q8","CSD17577Q3A","CSD17577Q3A","AI_MCUTOOL:N_FET","1","封装几何仍需制造审查"
"Q9","CSD17577Q3A","CSD17577Q3A","AI_MCUTOOL:N_FET","1","封装几何仍需制造审查"
"Q10","CSD17577Q3A","CSD17577Q3A","AI_MCUTOOL:N_FET","1","封装几何仍需制造审查"
"Q11","CSD17577Q3A","CSD17577Q3A","AI_MCUTOOL:N_FET","1","封装几何仍需制造审查"
"Q12","CSD25402Q3A","CSD25402Q3A","AI_MCUTOOL:P_FET","1","封装几何仍需制造审查"
"Q13","CSD25402Q3A","CSD25402Q3A","AI_MCUTOOL:P_FET","1","封装几何仍需制造审查"
"Q14","MMBT3904","MMBT3904LT1G","Package_TO_SOT_SMD:SOT-23","1","封装几何仍需制造审查"
"R1","4.7k","RC0603FR-074K7L","Resistor_SMD:R_0603_1608Metric","1","封装几何仍需制造审查"
"R2","4.7k","RC0603FR-074K7L","Resistor_SMD:R_0603_1608Metric","1","封装几何仍需制造审查"
"R3","5.1k","RC0603FR-075K1L","Resistor_SMD:R_0603_1608Metric","1","封装几何仍需制造审查"
"R4","5.1k","RC0603FR-075K1L","Resistor_SMD:R_0603_1608Metric","1","封装几何仍需制造审查"
"R5","10k","RC0603FR-0710KL","Resistor_SMD:R_0603_1608Metric","1","封装几何仍需制造审查"
"R6","10k","RC0603FR-0710KL","Resistor_SMD:R_0603_1608Metric","1","封装几何仍需制造审查"
"R7","10k","RC0603FR-0710KL","Resistor_SMD:R_0603_1608Metric","1","封装几何仍需制造审查"
"R8","10k","RC0603FR-0710KL","Resistor_SMD:R_0603_1608Metric","1","封装几何仍需制造审查"
"R9","10k","RC0603FR-0710KL","Resistor_SMD:R_0603_1608Metric","1","封装几何仍需制造审查"
"R10","1k","RC0603FR-071KL","Resistor_SMD:R_0603_1608Metric","1","封装几何仍需制造审查"
"R11","1k","RC0603FR-071KL","Resistor_SMD:R_0603_1608Metric","1","封装几何仍需制造审查"
"R12","240","RC0603FR-07240RL","Resistor_SMD:R_0603_1608Metric","1","封装几何仍需制造审查"
"R13","680","RC0603FR-07680RL","Resistor_SMD:R_0603_1608Metric","1","封装几何仍需制造审查"
"R14","10k","RC0603FR-0710KL","Resistor_SMD:R_0603_1608Metric","1","封装几何仍需制造审查"
"R15","240","RC0603FR-07240RL","Resistor_SMD:R_0603_1608Metric","1","封装几何仍需制造审查"
"R16","680","RC0603FR-07680RL","Resistor_SMD:R_0603_1608Metric","1","封装几何仍需制造审查"
"R17","10k","RC0603FR-0710KL","Resistor_SMD:R_0603_1608Metric","1","封装几何仍需制造审查"
"R18","240","RC0603FR-07240RL","Resistor_SMD:R_0603_1608Metric","1","封装几何仍需制造审查"
"R19","680","RC0603FR-07680RL","Resistor_SMD:R_0603_1608Metric","1","封装几何仍需制造审查"
"R20","10k","RC0603FR-0710KL","Resistor_SMD:R_0603_1608Metric","1","封装几何仍需制造审查"
"R21","240","RC0603FR-07240RL","Resistor_SMD:R_0603_1608Metric","1","封装几何仍需制造审查"
"R22","680","RC0603FR-07680RL","Resistor_SMD:R_0603_1608Metric","1","封装几何仍需制造审查"
"R23","10k","RC0603FR-0710KL","Resistor_SMD:R_0603_1608Metric","1","封装几何仍需制造审查"
"R24","240","RC0603FR-07240RL","Resistor_SMD:R_0603_1608Metric","1","封装几何仍需制造审查"
"R25","680","RC0603FR-07680RL","Resistor_SMD:R_0603_1608Metric","1","封装几何仍需制造审查"
"R26","10k","RC0603FR-0710KL","Resistor_SMD:R_0603_1608Metric","1","封装几何仍需制造审查"
"R27","100 / 1206","RC1206FR-07100RL","Resistor_SMD:R_1206_3216Metric","1","封装几何仍需制造审查"
"R28","330","RC0603FR-07330RL","Resistor_SMD:R_0603_1608Metric","1","封装几何仍需制造审查"
"R29","10k","RC0603FR-0710KL","Resistor_SMD:R_0603_1608Metric","1","封装几何仍需制造审查"
"R30","100 / 1206","RC1206FR-07100RL","Resistor_SMD:R_1206_3216Metric","1","封装几何仍需制造审查"
"R31","330","RC0603FR-07330RL","Resistor_SMD:R_0603_1608Metric","1","封装几何仍需制造审查"
"R32","10k","RC0603FR-0710KL","Resistor_SMD:R_0603_1608Metric","1","封装几何仍需制造审查"
"R33","10k","RC0603FR-0710KL","Resistor_SMD:R_0603_1608Metric","1","封装几何仍需制造审查"
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